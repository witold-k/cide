## meta-layer/meta-cide/conf/layer.conf
```bitbake
BBPATH .= ":${LAYERDIR}"
BBFILES += "${LAYERDIR}/recipes-*/*/*.bb"

BB_NUMBER_PARSE_THREADS = "8"
BB_NUMBER_THREADS = "8"
```
