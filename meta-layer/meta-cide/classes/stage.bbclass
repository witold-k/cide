../../../modules/buildscripts/bitbake/classes/stage.bbclass