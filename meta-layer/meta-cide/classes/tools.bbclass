../../../modules/buildscripts/bitbake/classes/tools.bbclass