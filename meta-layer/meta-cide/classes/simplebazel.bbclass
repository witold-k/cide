../../../modules/buildscripts/bitbake/classes/simplebazel.bbclass