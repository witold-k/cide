../../../../../../buildscripts/bitbake/classes/simplemake.bbclass