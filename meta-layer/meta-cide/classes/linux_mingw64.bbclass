../../../modules/buildscripts/bitbake/classes/linux_mingw64.bbclass