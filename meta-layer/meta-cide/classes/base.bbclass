../../../modules/buildscripts/bitbake/classes/base.bbclass