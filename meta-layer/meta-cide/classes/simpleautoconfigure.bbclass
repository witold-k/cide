../../../../../../buildscripts/bitbake/classes/simpleautoconfigure.bbclass