../../../../../../buildscripts/bitbake/classes/compiler.bbclass