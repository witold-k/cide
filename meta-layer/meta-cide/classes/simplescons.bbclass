../../../../../../buildscripts/bitbake/classes/simplescons.bbclass