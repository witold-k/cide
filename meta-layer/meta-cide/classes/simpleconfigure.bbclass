../../../../../../buildscripts/bitbake/classes/simpleconfigure.bbclass