../../../modules/buildscripts/bitbake/classes/populate.bbclass