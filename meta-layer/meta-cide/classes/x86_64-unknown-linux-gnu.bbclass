../../../../../../buildscripts/bitbake/classes/x86_64-unknown-linux-gnu.bbclass