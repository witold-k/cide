../../../modules/buildscripts/bitbake/classes/arm-obreey-linux-gnueabi.bbclass