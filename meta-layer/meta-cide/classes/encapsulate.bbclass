../../../modules/buildscripts/bitbake/classes/encapsulate.bbclass