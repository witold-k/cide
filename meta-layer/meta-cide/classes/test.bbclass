../../../../../../buildscripts/bitbake/classes/test.bbclass