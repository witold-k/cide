../../../modules/buildscripts/bitbake/classes/arm-unknown-linux-gnueabihf.bbclass