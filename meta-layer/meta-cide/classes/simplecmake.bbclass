../../../../../../buildscripts/bitbake/classes/simplecmake.bbclass