../../../modules/buildscripts/bitbake/classes/simpleninja.bbclass