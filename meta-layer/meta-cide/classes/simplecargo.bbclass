../../../modules/buildscripts/bitbake/classes/simplecargo.bbclass