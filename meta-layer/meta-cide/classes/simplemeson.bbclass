../../../../../../buildscripts/bitbake/classes/simplemeson.bbclass