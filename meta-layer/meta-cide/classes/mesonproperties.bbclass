../../../../../../buildscripts/bitbake/classes/mesonproperties.bbclass