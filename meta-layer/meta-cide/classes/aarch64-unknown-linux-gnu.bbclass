../../../../../../buildscripts/bitbake/classes/aarch64-unknown-linux-gnu.bbclass