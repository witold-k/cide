SUMMARY = "googletest"
LICENSE = "CLOSED"
MODULE = "base/googletest"
SRCPV = "1"

inherit simplecmake encapsulate
