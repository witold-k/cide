SUMMARY = "cmph"
LICENSE = "CLOSED"
MODULE = "base/utf8proc"
SRCPV = "1"

inherit simplecmake encapsulate

