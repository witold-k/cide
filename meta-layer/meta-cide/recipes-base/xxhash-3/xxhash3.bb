SUMMARY = "xxHash-3"
LICENSE = "CLOSED"
MODULE = "base/xxHash-3"
SRCPV = "1"

inherit simplemake encapsulate

# python () {
#     from bbdepend import BBDepend as BD
#     BD.depends(d, "")
# }
# do_check_need_build[depends] += "${DEPEND_TARGETS}"

