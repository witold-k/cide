SUMMARY = "tree-sitter"
LICENSE = "CLOSED"
MODULE = "base/tree-sitter"
SRCPV = "1"

inherit simplecmake encapsulate
