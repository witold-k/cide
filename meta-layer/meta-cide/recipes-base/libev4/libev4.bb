S1UMMARY = "libev4"
LICENSE = "CLOSED"
MODULE = "base/libev-4.24"
SRCPV = "1"

inherit simpleconfigure encapsulate

