SUMMARY = "libtommath"
LICENSE = "CLOSED"
MODULE = "crypt/libtommath"
SRCPV = "1"

inherit simplecmake encapsulate

