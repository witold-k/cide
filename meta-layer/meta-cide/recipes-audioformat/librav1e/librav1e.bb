SUMMARY = "librav1e"
LICENSE = "CLOSED"
MODULE = "audioformat/rav1e"
SRCPV = "1"

#simplecargo encapsulate

