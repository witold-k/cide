SUMMARY = "libogg"
LICENSE = "CLOSED"
MODULE = "audioformat/ogg"
SRCPV = "1"

inherit simplecmake encapsulate

