SUMMARY = "libspeex"
LICENSE = "CLOSED"
MODULE = "audioformat/speex"
SRCPV = "1"

inherit simplemeson encapsulate

#python () {
#    from bbdepend import BBDepend as BD
#    BD.depends(d, "ogg oggz")
#}
#do_check_need_build[depends] += "${DEPEND_TARGETS}"

