SUMMARY = "zstd"
LICENSE = "CLOSED"
MODULE = "compress/zstd"
SRCPV = "1"

inherit simplecmake encapsulate
