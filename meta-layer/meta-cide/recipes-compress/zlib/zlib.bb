SUMMARY = "zlib"
LICENSE = "CLOSED"
MODULE = "compress/zlib"
SRCPV = "1"

inherit simplecmake encapsulate
