SUMMARY = "lrzsz"
LICENSE = "CLOSED"
MODULE = "ide/lrzsz"
SRCPV = "1"

#simplescons encapsulate

