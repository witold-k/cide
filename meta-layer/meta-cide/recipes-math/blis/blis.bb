SUMMARY = "blis"
LICENSE = "CLOSED"
MODULE = "math/blis"
SRCPV = "1"

inherit simpleconfigure encapsulate

CONFIGURE_NO_CC_SWITCHES = "True"
CONFIGURE_OPTIONS = "generic"
