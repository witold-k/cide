SUMMARY = "lapack"
LICENSE = "CLOSED"
MODULE = "math/lapack"
SRCPV = "1"

inherit simplecmake encapsulate
