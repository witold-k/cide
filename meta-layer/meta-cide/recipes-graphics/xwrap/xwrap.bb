SUMMARY = "xwrap"
LICENSE = "CLOSED"
MODULE = "graphics/xwrap"
SRCPV = "1"

