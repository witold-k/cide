SUMMARY = "oprncl headers"
LICENSE = "CLOSED"
MODULE = "graphics/OpenCL-Headers"
SRCPV = "1"

inherit simplecmake encapsulate

