inherit stage

SUMMARY = "wait till recipes-audio is finished"
LICENSE = "CLOSED"
MODULE = "(none)"
SRCPV = "1"

do_check_need_build[depends] += " \
"

