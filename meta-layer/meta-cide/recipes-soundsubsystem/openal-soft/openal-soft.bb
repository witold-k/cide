SUMMARY = "libopenal-soft"
LICENSE = "CLOSED"
MODULE = "soundsubsystem/openal-soft"
SRCPV = "1"

#simplecargo encapsulate

